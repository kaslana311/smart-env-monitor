# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1U; __TARGET_FPU_VFP; __FPU_USED=1U; __ARM_FEATURE_DSP=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\libraries\STM32F4xx_HAL\CMSIS\Include; ..\..\libraries\HAL_Drivers; ..\..\..\..\components\libc\compilers\common; ..\..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\components\drivers\spi; applications\Communication; board\CubeMX_Config\Inc; ..\..\PublicLib\Software\Queue; applications\IMU; ..\..\libraries\HAL_Drivers\drv_flash; ..\..\PublicLib\Software\Pid; ..\..\..\..\libcpu\arm\cortex-m4; applications\Aimbot; applications\Gun; ..\..\PublicLib\Software\Filter; .; ..\..\PublicLib\Software\CPU_Usage; board; ..\..\PublicLib\Software\SetPlanning; ..\..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; applications\GimbalCtrl; ..\..\..\..\components\drivers\include; ..\..\PublicLib\Monitor; ..\..\PublicLib\Software\Utils; applications\Magazine; ..\..\PublicLib\Software\Menu; ..\..\PublicLib\Hardware\Remote; ..\..\PublicLib\Software\Motor; applications\Main; ..\..\..\..\include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh; ..\..\PublicLib\Hardware\Buzzer; ..\..\libraries\HAL_Drivers\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Aimbot
    applications/Aimbot/: drv_Aimbot_Public.c drv_Aimbot_UARTCom.c drv_VisualTiming.c func_Aimbot_Com.c mod_aimbot_V2.c
  group Communication
    applications/Communication/: can_receive.c drv_UI_Flags.c drv_canthread.c func_ModCTR.c
  group GimbalCtrl
    applications/GimbalCtrl/: func_GimbalFB.c func_GimbalPID.c func_GimbalSet.c mod_gimbal.c drv_GimbalPublic.h
  group Gun
    applications/Gun/: drv_StrikeMotor.c drv_gundata.c func_gun.c drv_GunSettings.h
  group IMU
    applications/IMU/: drv_HWTimer.c drv_IMU.c drv_spithread.c func_IMUCali.c func_TempCtr.c func_ahrs.c func_bmi088.c mod_Atti.c
  group Public/Hardware/Magazine
    applications/Magazine/: drv_magazine.c
  group Main
    applications/Main/: app_MenuSet.c app_robocontrol.c func_KeyCallback.c func_MonitorCfg.c main.c drv_thread.h robodata.h roboselect.h
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_can.c drv_wdt.c drv_common.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group Public/Hardware/Buzzer
    ../../PublicLib/Hardware/Buzzer/: drv_buzzer.c
  group Public/Hardware/Remote
    ../../PublicLib/Hardware/Remote/: drv_remote.c
  group Public/Monitor
    ../../PublicLib/Monitor/NoMonitor/: app_monitor.h
  group Public/Hardware/Cpu_Usage
    ../../PublicLib/Software/CPU_Usage/: drv_cpuusage.c
  group Public/Software/Filter
    ../../PublicLib/Software/Filter/: drv_ExactSmooth.c
  group Public/Software/Menu
    ../../PublicLib/Software/Menu/: drv_Key_Set.h func_Key_Record.c mod_KeyCtrl.c
  group Public/Software/Motor
    ../../PublicLib/Software/Motor/: drv_motor.c
  group Public/Software/Pid
    ../../PublicLib/Software/Pid/: pid.c
  group Public/Software/Queue
    ../../PublicLib/Software/Queue/: drv_Queue.c
  group Public/Software/SetPlanning
    ../../PublicLib/Software/SetPlanning/: drv_SetPlanning.c
  group Public/Software/Utils
    ../../PublicLib/Software/Utils/: drv_utils.c
  group STM32_HAL
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
